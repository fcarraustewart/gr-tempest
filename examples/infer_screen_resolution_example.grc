options:
  parameters:
    author: gr-tempest
    generate_options: qt_gui
    id: infer_screen_resolution_example
    output_language: python
    title: infer_resolution_example
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: (4096)*(512)
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: (1/time_peak)*1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '19980000'
  states: {}
- name: time_peak
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Time_peak (us)
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '18000'
    value: '16666'
    widget: counter
  states: {}
- name: Autocorrelation_0
  id: Autocorrelation
  parameters:
    alpha: '1.0'
    fac_decimation: '10'
    fft_size: int(4096*512)
    sample_rate: int(50e6)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pablo/fing/proyecto/grabaciones/grabacion_splitter_50M_1344_806_px_freq_64995840.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int(4096*512/4)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int(4096*512/4)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: tempest_infer_screen_resolution_0
  id: tempest_infer_screen_resolution
  parameters:
    fft_size: fft_size
    refresh_rate: refresh_rate
    sample_rate: samp_rate
  states: {state: disabled}
- name: tempest_screen_resolution_inference_0
  id: tempest_screen_resolution_inference
  parameters:
    fft_size: fft_size
    refresh_rate: refresh_rate
    sample_rate: samp_rate
  states: {}

connections:
- [Autocorrelation_0, '0', qtgui_time_sink_x_0, '0']
- [Autocorrelation_0, '0', tempest_infer_screen_resolution_0, '0']
- [Autocorrelation_0, '0', tempest_screen_resolution_inference_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', Autocorrelation_0, '0']
- [tempest_infer_screen_resolution_0, '0', blocks_null_sink_0, '0']
- [tempest_infer_screen_resolution_0, '0', qtgui_time_sink_x_0_0, '0']
- [tempest_screen_resolution_inference_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
