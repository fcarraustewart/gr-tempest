options:
  parameters:
    generate_options: qt_gui
    id: semi_automatic_tempest_example
    output_language: python
  states: {}

blocks:
- name: Hblank
  id: variable
  parameters:
    value: Hsize-Hvisible
  states: {}
- name: Hcorrection
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Horizontal correction
    orient: Qt.Horizontal
    rangeType: int
    start: '-20'
    step: '1'
    stop: '20'
    value: '0'
    widget: counter
  states: {}
- name: Hdisplay
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hsize
  id: variable
  parameters:
    value: Hsizes[mode]
  states: {}
- name: Hsizes
  id: variable
  parameters:
    value: '[832, 936, 800, 848, 832, 840, 832, 976, 992, 1008, 1008, 1024, 1024, 1056, 1040, 1056, 1048, 1072, 1312, 1264, 1344, 1328, 1312, 1376, 1392, 1408, 1520, 1600, 1552, 1568, 1680, 1680, 1800, 1728, 1728, 1760, 1688, 1688, 1728, 1760, 1776, 1800, 1880, 1896, 1896, 1912, 1928, 1904, 1936, 2144, 2160, 2176, 2192, 2144, 2176, 2096, 2176, 2160, 2160, 2160, 2160, 2160, 2208, 1840, 2240, 2256, 2448, 2456, 2528, 2560, 2576, 2608, 2592, 2624, 2600, 2640, 2048, 2044, 2800]'
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: Hvisibles[mode]
  states: {}
- name: Hvisibles
  id: variable
  parameters:
    value: '[640, 720, 640, 640, 640, 640, 640, 768, 768, 768, 768, 768, 800, 800, 800, 800, 800, 800, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1152, 1152, 1152, 1152, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1368, 1400, 1400, 1400, 1400, 1400, 1440, 1440, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1680, 1680, 1680, 1792, 1792, 1856, 1856, 1920, 1920, 1920, 1920, 1920, 1920, 1920, 1920, 2048]'
  states: {}
- name: Vblank
  id: variable
  parameters:
    value: Vsize-Vvisible
  states: {}
- name: Vcorrection
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Vertical correction
    orient: Qt.Horizontal
    rangeType: int
    start: '-20'
    step: '1'
    stop: '20'
    value: '0'
    widget: counter
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: '768'
  states: {}
- name: Vsize
  id: variable
  parameters:
    value: Vsizes[mode]+Vcorrection
  states: {}
- name: Vsizes
  id: variable
  parameters:
    value: '[445, 446, 525, 509, 520, 500, 509, 597, 601, 602, 605, 611, 625, 628, 666, 625, 631, 636, 622, 817, 806, 806, 800, 808, 814, 823, 895, 900, 907, 915, 795, 828, 1000, 1002, 1011, 1017, 1066, 1066, 1072, 1085, 1097, 795, 1082, 1094, 1096, 1103, 1112, 932, 1087, 1035, 1044, 1050, 1059, 1060, 1069, 1070, 1075, 1250, 1250, 1250, 1250, 1250, 1271, 1080, 1089, 1087, 1394, 1417, 1439, 1500, 1125, 1126, 1242, 1253, 1500, 1500, 2434, 2434, 1589]'
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: Vvisibles[mode]
  states: {}
- name: Vvisibles
  id: variable
  parameters:
    value: '[400, 400, 480, 480, 480, 480, 480, 576, 576, 576, 576, 576, 600, 600, 600, 600, 600, 600, 600, 768, 768, 768, 768, 768, 768, 768, 864, 864, 864, 864, 768, 800, 960, 960, 960, 960, 1024, 1024, 1024, 1024, 1024, 768 , 1050, 1050, 1050, 1050, 1050, 900 , 1050, 1000, 1000, 1000, 1000, 1024, 1024, 1024, 1024, 1200, 1200, 1200, 1200, 1200, 1200, 1050, 1050, 1050, 1344, 1344, 1392, 1392, 1080, 1080, 1200, 1200, 1440, 1440, 2400, 2400, 1536] '
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*samp_rate)+Hcorrection
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: Display's resolution
    labels: modes
    num_opts: '0'
    options: range(len(modes))
    type: int
    value: '20'
  states: {}
- name: modes
  id: variable
  parameters:
    value: '["640x400 @ 85Hz", "720x400 @ 85Hz", "640x480 @ 60Hz", "640x480 @ 100Hz", "640x480 @ 72Hz", "640x480 @ 75Hz", "640x480 @ 85Hz", "768x576 @ 60 Hz", "768x576 @ 72 Hz", "768x576 @ 75 Hz", "768x576 @ 85 Hz", "768x576 @ 100 Hz", "800x600 @ 56Hz", "800x600 @ 60Hz", "800x600 @ 72Hz", "800x600 @ 75Hz", "800x600 @ 85Hz", "800x600 @ 100Hz", "1024x600 @ 60 Hz", "1024x768i @ 43Hz", "1024x768 @ 60Hz", "1024x768 @ 70Hz", "1024x768 @ 75Hz", "1024x768 @ 85Hz", "1024x768 @ 100Hz", "1024x768 @ 120Hz", "1152x864 @ 60Hz", "1152x864 @ 75Hz", "1152x864 @ 85Hz", "1152x864 @ 100Hz", "1280x768 @ 60 Hz", "1280x800 @ 60 Hz", "1280x960 @ 60Hz", "1280x960 @ 75Hz", "1280x960 @ 85Hz", "1280x960 @ 100Hz", "1280x1024 @ 60Hz", "1280x1024 @ 75Hz", "1280x1024 @ 85Hz", "1280x1024 @ 100Hz", "1280x1024 @ 120Hz", "1368x768 @ 60 Hz", "1400x1050 @ 60Hz", "1400x1050 @ 72 Hz", "1400x1050 @ 75 Hz", "1400x1050 @ 85 Hz", "1400x1050 @ 100 Hz", "1440x900 @ 60 Hz", "1440x1050 @ 60 Hz", "1600x1000 @ 60Hz", "1600x1000 @ 75Hz", "1600x1000 @ 85Hz", "1600x1000 @ 100Hz", "1600x1024 @ 60Hz", "1600x1024 @ 75Hz", "1600x1024 @ 76Hz", "1600x1024 @ 85Hz", "1600x1200 @ 60Hz", "1600x1200 @ 65Hz", "1600x1200 @ 70Hz", "1600x1200 @ 75Hz", "1600x1200 @ 85Hz", "1600x1200 @ 100 Hz", "1680x1050 @ 60Hz  reduced blanking ", "1680x1050 @ 60Hz  non-interlaced ", "1680x1050 @ 60 Hz", "1792x1344 @ 60Hz", "1792x1344 @ 75Hz", "1856x1392 @ 60Hz", "1856x1392 @ 75Hz", "1920x1080 @ 60Hz", "1920x1080 @ 75Hz", "1920x1200 @ 60Hz", "1920x1200 @ 75Hz", "1920x1440 @ 60Hz", "1920x1440 @ 75Hz", "1920x2400 @ 25Hz", "1920x2400 @ 30Hz", "2048x1536 @ 60Hz"]'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: refresh_rates[mode]
  states: {}
- name: refresh_rates
  id: variable
  parameters:
    value: '[85, 85, 60, 100, 72, 75, 85, 60, 72, 75, 85, 100, 56, 60, 72, 75, 85, 100, 60, 43, 60, 70, 75, 85, 100, 120, 60, 75, 85, 100, 60, 60, 60, 75, 85, 100,  60,  75,  85,  100,  120, 60,  60,  72,  75,  85,  100 , 60,  60,  60,  75,  85,  100,  60,  75,  76,  85,  60,  65,  70,  75,  85,  100 ,  60,  60,  60,  60,  75,  60,  75,  60,  75,  60,  75,  60,  75,  25,  30,  60]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(19989200)
  states: {}
- name: FFT_autocorrelation_0
  id: FFT_autocorrelation
  parameters:
    fac_decimation: '10'
    fft_size: int(4096*512)
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize*lines_offset+horizontal_offset
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/victoria/GNUfiles/grabaciones/test3_19980KHz_1152_864.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {}
- name: blocks_float_to_short_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: 10.0/interpolatedHsize
    update_proba: 1e-2/(Hsize*Vsize)
  states: {}
- name: tempest_framing_0
  id: tempest_framing
  parameters:
    Hdisplay: Hdisplay
    Htotal: interpolatedHsize
    Vdisplay: Vdisplay
    Vtotal: Vsize
  states: {state: disabled}
- name: tempest_infer_resolution_0
  id: tempest_infer_resolution
  parameters:
    Hvisible: Hvisible
    Vvisible: Vvisible
    automatic_mode: bool(0)
    refresh_rate: refresh_rate
    sample_rate: samp_rate
    size: int(4096*512)
  states: {state: disabled}
- name: tempest_message_to_var_0
  id: tempest_message_to_var
  parameters:
    target: refresh_rate
  states: {state: disabled}
- name: tempest_message_to_var_0_0
  id: tempest_message_to_var
  parameters:
    target: Vvisible
  states: {state: disabled}
- name: tempest_message_to_var_0_0_0
  id: tempest_message_to_var
  parameters:
    target: Vblank
  states: {state: disabled}
- name: tempest_message_to_var_0_0_0_0
  id: tempest_message_to_var
  parameters:
    target: Hvisible
  states: {state: disabled}
- name: tempest_message_to_var_0_0_0_0_0
  id: tempest_message_to_var
  parameters:
    target: Hblank
  states: {state: disabled}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: px_rate*harmonic
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: video_sdl_sink_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are not sure what the 
      resolution is and you want to try several ones 
      on run-time. Then, enable the other path.
    display_height: Vdisplay
    display_width: Hdisplay
    fps: '0'
    height: Vdisplay
    type: short
    width: Hdisplay
  states: {state: disabled}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [FFT_autocorrelation_0, '0', tempest_infer_resolution_0, '0']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_float_to_short_0_0_0, '0', video_sdl_sink_0_0, '0']
- [blocks_throttle_0, '0', FFT_autocorrelation_0, '0']
- [blocks_throttle_0, '0', tempest_fine_sampling_synchronization_0, '0']
- [tempest_fine_sampling_synchronization_0, '0', blocks_delay_0, '0']
- [tempest_framing_0, '0', blocks_float_to_short_0_0_0, '0']
- [tempest_infer_resolution_0, '0', blocks_null_sink_0, '0']
- [tempest_infer_resolution_0, Hblank, tempest_message_to_var_0_0_0_0_0, port0]
- [tempest_infer_resolution_0, Hvisible, tempest_message_to_var_0_0_0_0, port0]
- [tempest_infer_resolution_0, Vblank, tempest_message_to_var_0_0_0, port0]
- [tempest_infer_resolution_0, Vvisible, tempest_message_to_var_0_0, port0]
- [tempest_infer_resolution_0, refresh_rate, tempest_message_to_var_0, port0]
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0_0, '0']
- [tempest_normalize_flow_0, '0', tempest_framing_0, '0']
- [uhd_usrp_source_0, '0', tempest_fine_sampling_synchronization_0, '0']

metadata:
  file_format: 1
