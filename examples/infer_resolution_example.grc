options:
  parameters:
    generate_options: qt_gui
    id: INFER_RESOLUTION
    output_language: python
    title: infer_resolution_example
  states: {}

blocks:
- name: refresh_rate
  id: variable
  parameters:
    value: (1/time_peak)*1e6
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '60'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '19980000'
  states: {}
- name: time_peak
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Time_peak (us)
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '18000'
    value: '13333'
    widget: counter
  states: {}
- name: FFT_autocorrelation_0
  id: FFT_autocorrelation
  parameters:
    fac_decimation: '10'
    fft_size: int(4096*512)
    sample_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/victoria/GNUfiles/grabaciones/test2_19980KHz_1920_1080.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: int(4096*512/256)
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int(4096*512/4)
    srate: samp_rate
    type: float
  states: {}
- name: tempest_infer_screen_resolution_0
  id: tempest_infer_screen_resolution
  parameters:
    fft_size: int(4096*512)
    refresh_rate: refresh_rate
    sample_rate: samp_rate
  states: {}

connections:
- [FFT_autocorrelation_0, '0', qtgui_freq_sink_x_0, '0']
- [FFT_autocorrelation_0, '0', qtgui_time_sink_x_0, '0']
- [FFT_autocorrelation_0, '0', tempest_infer_screen_resolution_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', FFT_autocorrelation_0, '0']
- [tempest_infer_screen_resolution_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
