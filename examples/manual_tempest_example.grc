options:
  parameters:
    generate_options: qt_gui
    id: manual_tempest_example
    output_language: python
  states: {}

blocks:
- name: Hblank
  id: variable
  parameters:
    value: Hsize - Hdisplay
  states: {}
- name: Hdisplay
  id: variable
  parameters:
    value: '1152'
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1,1
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '2200'
    widget: counter
  states: {}
- name: Vblank
  id: variable
  parameters:
    value: Vsize - Vdisplay
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: '720'
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1,1
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '1500'
    widget: counter
  states: {}
- name: Vsize
  id: variable
  parameters:
    value: '1125'
  states: {state: disabled}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '3'
  states: {state: disabled}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {state: disabled}
- name: interpolatedHblank
  id: variable
  parameters:
    value: int(Hblank/float(px_rate)*samp_rate)
  states: {state: disabled}
- name: interpolatedHdisplay
  id: variable
  parameters:
    value: int(Hdisplay/float(px_rate)*samp_rate)
  states: {state: disabled}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*samp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,0,1,1
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {state: disabled}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Refresh Rate (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240'
    value: '75'
    widget: counter
  states: {state: disabled}
- name: refresh_rate
  id: variable
  parameters:
    value: (1/time_peak)*1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16065000'
  states: {}
- name: time_est
  id: variable_qtgui_range
  parameters:
    label: time_est
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: samp_rate/refresh_rate
  states: {state: disabled}
- name: time_peak
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Time_peak (us)
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '18000'
    value: '13333'
    widget: counter
  states: {}
- name: FFT_autocorrelation_0
  id: FFT_autocorrelation
  parameters:
    alpha: '1.0'
    fac_decimation: '10'
    fft_size: int(4096*512)
    sample_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize*lines_offset+horizontal_offset
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/victoria/GNUfiles/grabaciones/test_19.9530382MHz_832_624.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/felipe/gnuradio/git/grabaciones_local/16con065megahertz4.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: int(4096*512/4)
    srate: samp_rate
    type: float
  states: {}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: 10.0/interpolatedHsize
    update_proba: 1e-2/(Hsize*Vsize)
  states: {state: disabled}
- name: tempest_frame_drop_0
  id: tempest_frame_drop
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    actual_samp_rate: samp_rate
    correct_sampling: '1'
    max_deviation: 100.0/interpolatedHsize
    update_proba: 1.2e-1/(interpolatedHsize*Vsize)
  states: {}
- name: tempest_infer_resolution_0
  id: tempest_infer_resolution
  parameters:
    Hvisible: Hdisplay
    Vsize: Vsize
    automatic_mode: bool('0')
    refresh_rate: int(refresh_rate)
    sample_rate: samp_rate
    size: int(4096*512)
  states: {}
- name: tempest_message_to_var_0
  id: tempest_message_to_var
  parameters:
    target: refresh_rate
  states: {state: disabled}
- name: tempest_message_to_var_0_0
  id: tempest_message_to_var
  parameters:
    target: Vdisplay
  states: {state: disabled}
- name: tempest_message_to_var_0_0_0
  id: tempest_message_to_var
  parameters:
    target: Vsize
  states: {state: disabled}
- name: tempest_message_to_var_0_0_0_0
  id: tempest_message_to_var
  parameters:
    target: Hdisplay
  states: {state: disabled}
- name: tempest_message_to_var_0_0_0_0_0
  id: tempest_message_to_var
  parameters:
    target: Hsize
  states: {state: disabled}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {state: disabled}
- name: tempest_sync_detector_0
  id: tempest_sync_detector
  parameters:
    hblanking: interpolatedHblank
    hscreen: interpolatedHdisplay
    vblanking: Vblank
    vscreen: Vdisplay
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    bw0: 15e6
    center_freq0: px_rate*harmonic
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {state: disabled}

connections:
- [FFT_autocorrelation_0, '0', qtgui_time_sink_x_0, '0']
- [FFT_autocorrelation_0, '0', tempest_infer_resolution_0, '0']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_throttle_0, '0', tempest_fine_sampling_synchronization_0, '0']
- [blocks_throttle_0, '0', tempest_frame_drop_0, '0']
- [tempest_fine_sampling_synchronization_0, '0', blocks_delay_0, '0']
- [tempest_fine_sampling_synchronization_0, '0', tempest_sync_detector_0, '0']
- [tempest_frame_drop_0, '0', FFT_autocorrelation_0, '0']
- [tempest_infer_resolution_0, '0', blocks_null_sink_0, '0']
- [tempest_infer_resolution_0, Vsize, FFT_autocorrelation_0, en]

metadata:
  file_format: 1
